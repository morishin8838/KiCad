# Repository morishin8838/KiCad

File README.md:

# kicad
* 実験用に製作したカスタム基板の設計資料です

## KiCad design SLG46826G_実験評価用基板/回路図/src/20221225_SLG46826G.kicad_pcb

File SLG46826G_実験評価用基板/回路図/README.md:

# 実験評価用基板

## 回路図
* 

## Kicad Projectデータ
* src

Parts:
C1, C2, C3, C4: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_TopOnly
IC1: SLG46826G; SOP65P640X120-20N; Manufacturer_Part_Number SLG46826G; Mouser Part Number 724-SLG46826G
J1: GROVE-CONNECTOR-DIP_4P-2.0_; HW4-2.0
J2, J3: Conn_01x20_Male; PinHeader_1x20_P2.54mm_Vertical
J4, J5, J6: Conn_01x15_Male; PinHeader_1x15_P2.54mm_Vertical
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Bridged2Bar_Pad1.0x1.5mm
JP2: Jumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged2Bar12_Pad1.0x1.5mm_NumberLabe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
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: MCP1703A-3302_SOT23; SOT-23

Connections:
3V3: C4.1, JP2.3 (B), U1.2 (VO)
GND: C1.2, C2.2, C3.2, C4.2, H1.1, H2.1, H3.1, H4.1, IC1.10 (GND), J1.4, J2.2, J3.2, J6.1, J6.2, J6.3, J6.4, J6.5, J6.6, J6.7, J6.8, J6.9, J6.10, J6.11, J6.12, J6.13, J6.14, J6.15, JP1.2 (B), R1.2, R2.2, U1.1 (GND)
IO0: D3.2 (A), IC1.19 (IO0), J2.6, J3.6, J5.1
IO1: D4.2 (A), IC1.18 (IO1), J2.7, J3.7, J5.2
IO2: D5.2 (A), IC1.17 (IO2), J2.8, J3.8, J5.3
IO3: D6.2 (A), IC1.16 (IO3), J2.9, J3.9, J5.4
IO4: D7.2 (A), IC1.15 (IO4), J2.10, J3.10, J5.5
IO5: D8.2 (A), IC1.14 (IO5), J2.11, J3.11, J5.6
IO6: D9.2 (A), IC1.11 (IO6), J2.12, J3.12, J5.7
IO7: D10.2 (A), IC1.9 (IO7), J2.13, J3.13, J5.8
IO8: D11.2 (A), IC1.8 (IO8), J2.14, J3.14, J5.9
IO9: D12.2 (A), IC1.6 (IO9), J2.15, J3.15, J5.10
IO10: D13.2 (A), IC1.5 (IO10), J2.16, J3.16, J5.11
IO11: D14.2 (A), IC1.4 (IO11), J2.17, J3.17, J5.12
IO12: D15.2 (A), IC1.3 (IO12), J2.18, J3.18, J5.13
IO13: D16.2 (A), IC1.2 (IO13), J2.19, J3.19, J5.14
IO14: D17.2 (A), IC1.1 (IO14), J2.20, J3.20, J5.15
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: D6.1 (K), R6.1
unnamed: D7.1 (K), R7.1
unnamed: D8.1 (K), R8.1
unnamed: D9.1 (K), R9.1
unnamed: D10.1 (K), R10.1
unnamed: D11.1 (K), R11.1
unnamed: D12.1 (K), R12.1
unnamed: D13.1 (K), R13.1
unnamed: D14.1 (K), R14.1
unnamed: D15.1 (K), R15.1
unnamed: D16.1 (K), R16.1
unnamed: D17.1 (K), R17.1
unnamed: JP1.1 (A), R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2
SCL: IC1.13 (SCL), J1.1, J2.4, J3.4
SDA: IC1.12 (SDA), J1.2, J2.5, J3.5
VCC: C2.1, C3.1, D1.2 (A), IC1.20 (VDD), J1.3, J2.1, J3.1, J4.1, J4.2, J4.3, J4.4, J4.5, J4.6, J4.7, JP2.1 (A), U1.3 (VI)
VDD2: C1.1, D2.2 (A), IC1.7 (VDD2), J2.3, J3.3, J4.8, J4.9, J4.10, J4.11, J4.12, J4.13, J4.14, J4.15, JP2.2 (C)

Notes on the sheet:
5V=>3.3V
PU/PDジャンパ 通常Open
出力表示LED
VDD2電圧選択
入力出力信号への接続コネクタ

Board: 2 copper layers, 71.1 x 71.1 mm, 52 parts (0 on the bottom side), 39 nets.

## Commit log

2022-12-24 SLG46826G_実験評価用基板
2022-12-24 雛形ディレクトリ追加
2022-12-24 名称変更
2022-12-25 SLG46826G_実験評価用基板 pcbfusion発注データ
2022-12-25 pcbfusion発注内容
2022-12-25 回路図追加
2022-12-25 部品発注フォルダ追加
2022-12-27 update SLG46826G_実験評価用基板
2022-12-27 update 回路図
2022-12-27 add 部品注文
